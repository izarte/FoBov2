Commit message: Progress with sac and ppo and modify docker compose for second ppo rovit

File: fobo2_env/fobo2_env/src/models/wall.urdf (robot description, URDF)
Before this commit: robot box, 1 links, 0 joints
Links:
- link box: geometry collision box size=6 30 0.2; visual box size=6 30 0.2
